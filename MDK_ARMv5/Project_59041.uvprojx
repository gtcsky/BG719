# Keil uVision project Project_59041.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F59041 Holtek
  pack: Holtek.HT32_DFP.1.0.21
  cpu: IROM(0x00000000-0x0000FBFF) IRAM(0x20000000-0x20001FFF) CLOCK(20000000) CPUTYPE("Cortex-M0+")
  output: BG719 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F59041_SK, USE_HT32F59041, USE_MEM_HT32F59041
  c include: ..\;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F5xxxx\Include;..\library\HT32F5xxxx_Driver\inc;..\library\HT32_USBD_Library\inc;..\utilities;..\User\inc;..\utilities\common
  asm define: USE_HT32_CHIP=8
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group User
    ../User/src/: ht32f5xxxx_01_it.c main.c user_adc.c user_menu.c user_lptimer.c user_basetime.c user_exti.c user_key.c user_advtime.c user_tone.c user_i2c.c user_lcd.c user_spi.c user_datastore.c user_ddl.c
  group Config
    ../: ht32f5xxxx_conf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_04.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_02.s
  group Library
    ../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_div.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../utilities/: ht32_board.c
    ../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
